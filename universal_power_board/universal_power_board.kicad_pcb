# Repository hornet0018/universal_power_board

## KiCad design universal_power_board/universal_power_board.kicad_pcb

Parts:
C1: 22uF 25V; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 10uF 10V; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380_Pad
J1: Conn_01x03_Male; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J2: BATT INPUT; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J3, J6, J11, J12: BATT OUTPUT; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J4, J5, J7, J8, J9, J10: 5V OUTPUT; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R1: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 150; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 20K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 1.33K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 300; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: OKL-T_6-W12N-C; OKL-T_3-W5; Manufacturer_Part_Number OKL-T/6-W12N-C; Mouser Part Number 580-OKL-T/6-W12N-C

Connections:
+5V: C2.1, D1.2 (A), J1.1, J4.1, J5.1, J7.1, J8.1, J9.1, J10.1, R3.1, U1.4, U1.5
+BATT: C1.1, J2.2, J3.2, J6.2, J11.2, J12.2, R1.1, U1.2
GND: C1.2, C2.2, J1.3, J2.1, J3.1, J4.2, J5.2, J6.1, J7.2, J8.2, J9.2, J10.2, J11.1, J12.1, R2.2, R3.2, R4.2, R5.2, U1.1, U1.3, U1.7
unnamed: D1.1 (K), R5.1
unnamed: J1.2, R1.2, R2.1
unnamed: R4.1, U1.6

Board: 2 copper layers, 41.0 x 41.0 mm, 25 parts (0 on the bottom side), 6 nets.

## Commit log

2021-02-24 v1.2作業中
2021-02-24 v1.2プロジェクト作成
2021-06-19 v1.3
2021-07-23 ステンシルデータ作成
2022-07-14 kicad6対応
